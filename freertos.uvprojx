# Keil uVision project freertos.uvprojx, settings and files
target Target 1 (5060300::V5.06 update 3 (build 300)::ARMCC)
  device: STM32F103RC STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IRAM(0x20000000,0xC000) IROM(0x08000000,0x40000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: freertos +hex
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F10X_HD,USE_STDPERIPH_DRIVER
  c include: .\USER\Source\include;.\USER\Source\portable\RVDS\ARM_CM3;.\SYSTEM\sys;.\SYSTEM\delay;.\SYSTEM\usart;.\CORE;.\HARDWARE\LED;.\STM32F10x_FWLib\inc;.\USER
  asm include: .\CORE
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
  group USER
    ./USER/: main.c stm32f10x_it.c system_stm32f10x.c frtos.c
  group CORE
    ./CORE/: core_cm3.c startup_stm32f10x_hd.s
  group SYSTEM
    ./SYSTEM/delay/: delay.c
    ./SYSTEM/sys/: sys.c
    ./SYSTEM/usart/: usart.c
  group HARDWARE
    ./HARDWARE/LED/: led.c
    ./HARDWARE/TIMER/: timer.c
    ./HARDWARE/LCD/: lcd.c
  group STM32F10x_FWLib
    ./STM32F10x_FWLib/src/: stm32f10x_usart.c stm32f10x_gpio.c stm32f10x_rcc.c misc.c stm32f10x_tim.c
  group RTOS_CORE
    ./USER/Source/: croutine.c event_groups.c list.c queue.c tasks.c timers.c
  group PORTABLE
    ./USER/Source/portable/MemMang/: heap_4.c
    ./USER/Source/portable/RVDS/ARM_CM3/: port.c
  group GKI
    ./USER/GKI/LOG/src/: gki_log.c
